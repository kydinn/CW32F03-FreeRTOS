# Keil uVision project freertos.uvprojx, settings and files
target freertos (ARM-ADS)
  device: CW32F030F8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.4
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Core;..\Middlewares\Third_Party\FreeRTOS;..\Middlewares\Third_Party\FreeRTOS\include;..\Middlewares\Third_Party\FreeRTOS\portable\RVDS\ARM_CM0;..\BSP\clock;..\BSP\uart;..\BSP;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler --pad=0xff
  group Core
    ../Core/: cw32f030_adc.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_pwr.c cw32f030_rcc.c cw32f030_spi.c cw32f030_uart.c interrupts_cw32f030.c system_cw32f030.c
  group App
    ../App/: main.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group BSP
    ../BSP/: startup_cw32f030.s bsp.c
    ../BSP/clock/: clock.c
    ../BSP/uart/: uart.c
software components: CMSIS:CORE 3.40.0
